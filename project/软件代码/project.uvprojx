# Keil uVision project project.uvprojx, settings and files
target STM3210E_RELEASE (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32-cloudsfaebox0627-1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,__FreeBSD__,DEBUG_BOOT=0,DEBUG_SHELL=0
  c include: ..\..\Libraries\inc;.\code\Bsp;.\code\Drv\LCD12864;.\code\Drv\keyboard;.\code\Drv\TIM\PWM_Output;..\..\Libraries;.\code\Drv\ADC1_DMA;.\code\Drv\lf125k;.\code\Drv\eeprom;.\code\Drv\ultrasonic;.\code\Drv\RTC;.\code\Drv\SysTick;.\code\Drv\USART;.\code\Drv\TIM\timer;.\code\Drv\SegLED;.\code\Drv\Buzzer;.\code\Drv\IR_Alert;.\code\Drv\Door;.\code\Drv\uart4;.\code\system;.\code\app;.\code\WiFiToCloud;.\code\Drv\Numcal;.\code\Drv\cjson;.\code\Drv\TIM;.\code\Drv\Ldr
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./code/: main.c
    ./code/app/: app_pwd.c
  group Drv
    ./code/Drv/LCD12864/: LCD12864.c
    ./code/Drv/keyboard/: keyboard_drv.c
    ./code/Drv/ADC1_DMA/: adc.c
    ./code/Drv/eeprom/: eeprom.c eeprom_flash.c
    ./code/Drv/lf125k/: lf125k.c
    ./code/Drv/ultrasonic/: ultrasonic.c
    ./code/Drv/RTC/: rtc.c
    ./code/Drv/SysTick/: systick.c
    ./code/Drv/USART/: usart.c
    ./code/Drv/SegLED/: SegLED_16bit.c
    ./code/Drv/Buzzer/: buzzer.c
    ./code/Drv/IR_Alert/: ir_alert.c
    ./code/Drv/Door/: door.c
    ./code/Drv/uart4/: hal_uart4.c
    ./code/Drv/Numcal/: numcal.c
    ./code/Drv/cjson/: cJSON.c
    ./code/Drv/TIM/timer/: hal_timer2.c
    ./code/Drv/TIM/PWM_Output/: pwm_output.c
  group Bsp
    ./code/Bsp/: My_InitTask.c bsp_flash.c
    ./code/: stm32f10x_it.c
  group Libraries
    ../../Libraries/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_i2c.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
    ../../Libraries/: system_stm32f10x.c
  group Startup
    ../../Libraries/: core_cm3.c
    ../../Startup/: startup_stm32f10x_hd.s
  group system
    ./code/system/: sys.c
  group WiFi To Cloud
    ./code/WiFiToCloud/: HAL_WiFiToCloud.c WiFiToCloud.c CloudReference.h
